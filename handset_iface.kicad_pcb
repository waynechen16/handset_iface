# Repository waynechen16/handset_iface

File README.md:

# handset_iface — RJ9 電話話筒 ↔ PC Line In / Line Out 轉接板

把類比電話話筒（RJ9 / 4P4C）接到電腦的 line out 與 line in，並用中介電路處理阻抗與電平，讓音量不掉。

目前版本：**Rev B**（新增 J2 話筒腳位選擇跳線 JP1–JP6）

## 電路概要

| 區塊 | 內容 |
|---|---|
| 路徑 A：PC line out → 聽筒 | J1 → R1/R2（L+R 混成單聲道）→ C1 → RV1 音量 → U1 LM386（Av = 20）→ C5 / R3 → EAR+；R4 + C6 為 Zobel |
| 路徑 B：麥克風 → PC line in | electret 麥克風，R5 提供偏壓 → C8 → U2A MCP6022 前級（Av = 5.5 ~ 51，RV2 調整）→ C11 / R10 → J3 |
| VREF | R11 / R12 分壓 + U2B 緩衝，提供 2.5 V 虛擬地 |
| 電源 | J4 USB-B 取 5 V → FB1 / C14；R6 / C7 濾波後給前級（+5V_FILT） |
| 話筒腳位選擇 | JP1–JP6 焊接跳線，見下節 |

## 話筒腳位選擇跳線（Rev B）

市面上的類比話筒，聽筒與麥克風的腳位組合不只一種，electret 麥克風也有極性。JP1–JP6 都是三墊式焊接跳線，出廠時 1–2 以銅箔預先短接（預設），要改設定時用刀片切斷 1–2 之間的細銅，再用錫把 2–3 接起來。

| 跳線 | 作用 | 1–2（預設） | 2–3 |
|---|---|---|---|
| JP1–JP4（四個一起改） | 聽筒 / 麥克風對調 | J2.1 = 聽筒 EAR+、J2.4 = 聽筒 GND、J2.2 / J2.3 = 麥克風 | J2.2 = 聽筒 EAR+、J2.3 = 聽筒 GND、J2.1 / J2.4 = 麥克風 |
| JP5–JP6（兩個一起改） | 麥克風極性 | 麥克風對的第一腳（MA）= MIC+，第二腳（MB）= GND | MA = GND，MB = MIC+ |

預設設定（全部 1–2）與 Rev A 的接法相同：J2 pin 1/4 = 聽筒，pin 2 = MIC+，pin 3 = MIC GND。

判斷方式：用三用電表量話筒線，聽筒那一對約 30–300 Ω 且正反向讀值相同；electret 麥克風那一對正反向讀值不同。麥克風極性最可靠的判斷是看膠囊本體：與金屬外殼相連的那一腳是 GND，另一腳是 MIC+。無法拆開時，也可以先用預設值試，沒有聲音或聲音極小再改 JP5–JP6。

## PCB

- 80 × 60 mm，兩層板，四角 M3 安裝孔
- 下緣由左到右：J1 LINE OUT、J3 LINE IN、RV1 VOL（Alps RK097，軸伸出板外）、J4 USB-B
- 上緣：J2 RJ9；J2 右側一排為 JP4、JP3、JP2、JP1（PAIR）與 JP5、JP6（MIC POL）
- 被動元件、IC 為 SMT（0805 / 1206 / SOIC-8）；J1–J4 與 RV1 為 THT；JP1–JP6 為 PCB 銅箔，不需零件
- 設計規則：clearance 0.2 mm，訊號線 0.3 mm，電源線 0.5 mm，via 0.6 / 0.3 mm；底層為 GND 平面

## 檔案

| 檔案 | 說明 |
|---|---|
| `handset_iface.kicad_pro / .kicad_sch / .kicad_pcb` | KiCad 專案 |
| `handset_iface_sch.pdf` | 原理圖 PDF |
| `pcb_top.png`, `pcb_bottom.png` | PCB 正反面預覽 |
| `handset_iface_gerber.zip` | Gerber + Excellon 鑽孔檔（送板廠） |
| `handset_iface_pos_top.csv` | SMT 座標檔（原點：板子左下角） |
| `handset_iface_BOM.csv` | BOM（跳線為銅箔，不列入） |
| `scripts/` | 產生原理圖、擺放、自動佈線、預覽所用的 Python 腳本（KiCad 7 pcbnew API；路徑為產生時的環境，需自行調整） |

## 版本紀錄

- **Rev B**：新增 J2 腳位選擇跳線 JP1–JP6（聽筒 / 麥克風對調、麥克風極性）
- **Rev A**：初版原理圖與兩層板 layout

## KiCad design handset_iface.kicad_pcb

Parts:
C1, C4, C11, C12: 10uF; C_1206_3216Metric
C2, C13: 100nF; C_0805_2012Metric
C5: 220uF; CP_Elec_6.3x7.7
C6: 47nF; C_0805_2012Metric
C7, C14: 100uF; CP_Elec_6.3x5.4
C8: 1uF; C_0805_2012Metric
C9: 47pF; C_0805_2012Metric
C10: 22uF; C_1206_3216Metric
FB1: 600R@100MHz; L_0805_2012Metric
J1: LINE OUT (from PC); Jack_3.5mm_CUI_SJ1-3523N_Horizontal
J2: RJ9 HANDSET; RJ9_Evercom_5301-440xxx_Horizontal
J3: LINE IN (to PC); Jack_3.5mm_CUI_SJ1-3523N_Horizontal
J4: USB-B (5V only); USB_B_Lumberg_2411_02_Horizontal
JP1, JP2, JP3, JP4: PAIR; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
JP5, JP6: MIC POL; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
R1, R2, R8, R11, R12: 10k; R_0805_2012Metric
R3: 47R; R_0805_2012Metric
R4: 10R; R_0805_2012Metric
R5, R9: 2.2k; R_0805_2012Metric
R6, R10: 100R; R_0805_2012Metric
R7: 100k; R_0805_2012Metric
RV1: 10k VOL; Potentiometer_Alps_RK097_Single_Horizontal
RV2: 100k GAIN; Potentiometer_Bourns_3314J_Vertical
U1: LM386M (SOIC-8); SOIC-8_3.9x4.9mm_P1.27mm
U2: MCP6022-E/SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C2.1, C14.1, FB1.2, R6.1, U1.6 (V+)
/+5V_FILT: C7.1, C13.1, R5.1, R6.2, R11.1, U2.8 (V+)
/EAR+: JP1.1 (A), JP2.3 (B), R3.2
/MA: JP1.3 (B), JP2.1 (A), JP5.2 (C)
/MB: JP3.1 (A), JP4.3 (B), JP6.2 (C)
/MIC+: C8.1, JP5.1 (A), JP6.3 (B), R5.2
/VREF: C10.2, R7.1, U2.6 (-), U2.7
GND: C2.2, C4.2, C6.2, C7.2, C12.2, C13.2, C14.2, J1.S, J3.S, J4.4 (GND), J4.5 (Shield), JP3.3 (B), JP4.1 (A), JP5.3 (B), JP6.1 (A), R12.2, RV1.3, U1.2 (-), U1.4 (GND), U2.4 (V-)
unnamed: C1.1, R1.2, R2.2
unnamed: C1.2, RV1.1
unnamed: C5.1, R4.1, U1.5
unnamed: C5.2, R3.1
unnamed: C6.1, R4.2
unnamed: C10.1, R9.2
unnamed: C9.1, C11.1, R8.1, U2.1
unnamed: C11.2, R10.1
unnamed: J1.R, R2.1
unnamed: J1.T, R1.1
unnamed: J3.R, J3.T, R10.2
unnamed: FB1.1, J4.1 (VBUS)
unnamed: J2.1, JP1.2 (C)
unnamed: J2.2, JP2.2 (C)
unnamed: J2.3, JP3.2 (C)
unnamed: J2.4, JP4.2 (C)
unnamed: R8.2, RV2.1
unnamed: RV1.2, U1.3 (+)
unnamed: C4.1, U1.7 (BYPASS)
unnamed: C8.2, R7.2, U2.3 (+)
unnamed: C9.2, R9.1, RV2.2, RV2.3, U2.2 (-)
unnamed: C12.1, R11.2, R12.1, U2.5 (+)

Notes on the sheet:
PATH A : PC LINE OUT -> LM386 (Av=20) -> Handset receiver 路徑 A：電腦 line out → 聽筒
EAR+ -> J2 via JP1/JP2 (see PINOUT SELECT)
R1/R2: L+R mix to mono C1: DC block
R4+C6: Zobel network Receiver 150R: R3=47R Receiver 8~32R : R3=10R
PATH B : MIC -> MCP6022 preamp (Av 5.5~51) -> PC LINE IN 路徑 B：麥克風 → line in
R5: bias for electret mic
same signal to L and R
Gain: R8 = 10k fixed + RV2 (0~100k) => Av = 1 + (10k~110k)/2.2k = 5.5 ~ 51 (15~34 dB) C9 limits HF / RF pickup C10 sets LF corner: 1/(2*pi*2.2k*22u) = 3.3 Hz
U2B: VREF = 2.5 V buffered virtual ground
POWER : 5 V from PC USB (shares PC ground -> no ground loop) 電源與接地
D+ / D- unused: power only. FB1 + C14: HF filter on USB 5 V.
NOTES 設計說明
1. RJ9 (4P4C) pinout is NOT standardized. Measure first: - receiver pair: 30~300 ohm DC; electret mic pair: diode-like (asymmetric). - set JP1-JP4 (pair) and JP5-JP6 (mic polarity) to match the handset. 2. Path A: LM386 has low output impedance, so the receiver no longer loads the PC line out -> no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
J2 HANDSET PINOUT SELECT (solder jumpers, default = 1-2 bridged) 話筒腳位選擇跳線
JP1-JP4 = PAIR select (always set all four the same way) 1-2 (default): J2.1 = EAR+, J2.4 = EAR-/GND, J2.2 = MA, J2.3 = MB 2-3 : J2.2 = EAR+, J2.3 = EAR-/GND, J2.1 = MA, J2.4 = MB JP5-JP6 = MIC polarity (always set both the same way) 1-2 (default): MA = MIC+ (hot), MB = GND 2-3 : MA = GND, MB = MIC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

Board: 2 copper layers, 80.0 x 60.0 mm, 44 parts (0 on the bottom side), 30 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3

File handset_iface_BOM.csv:

Ref,Value,Footprint
C1,10uF,Capacitor_SMD:C_1206_3216Metric
C2,100nF,Capacitor_SMD:C_0805_2012Metric
C4,10uF,Capacitor_SMD:C_1206_3216Metric
C5,220uF,Capacitor_SMD:CP_Elec_6.3x7.7
C6,47nF,Capacitor_SMD:C_0805_2012Metric
C7,100uF,Capacitor_SMD:CP_Elec_6.3x5.4
C8,1uF,Capacitor_SMD:C_0805_2012Metric
C9,47pF,Capacitor_SMD:C_0805_2012Metric
C10,22uF,Capacitor_SMD:C_1206_3216Metric
C11,10uF,Capacitor_SMD:C_1206_3216Metric
C12,10uF,Capacitor_SMD:C_1206_3216Metric
C13,100nF,Capacitor_SMD:C_0805_2012Metric
C14,100uF,Capacitor_SMD:CP_Elec_6.3x5.4
FB1,600R@100MHz,Inductor_SMD:L_0805_2012Metric
J1,LINE OUT (from PC),Connector_Audio:Jack_3.5mm_CUI_SJ1-3523N_Horizontal
J2,RJ9 HANDSET,Connector_RJ:RJ9_Evercom_5301-440xxx_Horizontal
J3,LINE IN (to PC),Connector_Audio:Jack_3.5mm_CUI_SJ1-3523N_Horizontal
J4,USB-B (5V only),Connector_USB:USB_B_Lumberg_2411_02_Horizontal
R1,10k,Resistor_SMD:R_0805_2012Metric
R2,10k,Resistor_SMD:R_0805_2012Metric
R3,47R,Resistor_SMD:R_0805_2012Metric
R4,10R,Resistor_SMD:R_0805_2012Metric
R5,2.2k,Resistor_SMD:R_0805_2012Metric
R6,100R,Resistor_SMD:R_0805_2012Metric
R7,100k,Resistor_SMD:R_0805_2012Metric
R8,10k,Resistor_SMD:R_0805_2012Metric
R9,2.2k,Resistor_SMD:R_0805_2012Metric
R10,100R,Resistor_SMD:R_0805_2012Metric
R11,10k,Resistor_SMD:R_0805_2012Metric
R12,10k,Resistor_SMD:R_0805_2012Metric
RV1,10k VOL,Potentiometer_THT:Potentiometer_Alps_RK097_Single_Horizontal
RV2,100k GAIN,Potentiometer_SMD:Potentiometer_Bourns_3314J_Vertical
U1,LM386M (SOIC-8),Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
U2,MCP6022-E/SN,Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
